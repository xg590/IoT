options:
  parameters:
    description: GR 3.8.2.0
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '50000'
    max_dev: 5e3
    quad_rate: '200000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '44100'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '10'
    gain: '1'
    samp_rate: 2e6
    type: fir_filter_ccf
    width: 25e3
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '441'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: '462687500'
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
